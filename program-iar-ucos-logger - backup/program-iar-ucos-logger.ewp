# IAR project program-iar-ucos-logger.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U68JBD100 NXP LPC11U68JBD100
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCIncludePath2: $PROJ_DIR$; src; src/APP; src/DEV; src/BSP; src/BSP/lpc_core/lpc_board/board_common; src/BSP/lpc_core/lpc_board/boards_11u6x/nxp_lpcxpresso_11u68; src/BSP/lpc_core/lpc_chip/chip_11u6x/config_11U6X; src/BSP/lpc_core/lpc_chip/chip_11u6x; src/BSP/lpc_core/lpc_chip/chip_common; src/ucosii\sources; src/ucosii\ports
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NXP-program-ctrl.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: NXP-program - app-A.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE_M0PLUS
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: NXP-program-ucos.bin
  ILINK.IlinkIcfFile: NXP-program - app-B.icf
configuration release (ARM)
  as the first configuration, except:
  group (top)
    src/: main.c
  group APP
    src/APP/: CM.c CRC16.c DataFlash.c DataTransferArea.c GlobalVar.c IEC104.c LED.c log.c ModbusMaster.c RealTime.c Record.c SlaveUnit.c SubCollection.c tool.c Uart0Process.c Update.c WatchDog.c
  group BSP/board
    src/BSP/lpc_core/lpc_board/boards_11u6x/nxp_lpcxpresso_11u68/: board.c board_sysinit.c
  group BSP/chip
    src/BSP/lpc_core/lpc_chip/chip_11u6x/: adc_11u6x.c chip_11u6x.c clock_11u6x.c crc_11u6x.c dma_11u6x.c gpio_11u6x.c gpiogroup_11u6x.c i2c_11u6x.c i2cm_11u6x.c iocon_11u6x.c pinint_11u6x.c pmu_11u6x.c romdiv_11u6x.c rtc_11u6x.c sct_11u6x.c ssp_11u6x.c stopwatch_11u6.c syscon_11u6x.c sysinit_11u6x.c timer_11u6x.c uart_0_11u6x.c uart_n_11u6x.c wwdt_11u6x.c
    src/BSP/lpc_core/lpc_chip/chip_common/: eeprom.c flash.c
  group DEV
    src/DEV/: IIC_polling.c InEeprom.c InRtc.c InTIMER.c InWDT.c KEY_SCAN.c Memory.c SPI.c Usart.c
  group start
    src/BSP/startup_code/: iar_startup_lpc11u6x.s sysinit.c
  group ucos/ports
    src/ucosii/ports/: app_cfg.h app_hooks.c os_cfg.h os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ucos/sources
    src/ucosii/sources/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
