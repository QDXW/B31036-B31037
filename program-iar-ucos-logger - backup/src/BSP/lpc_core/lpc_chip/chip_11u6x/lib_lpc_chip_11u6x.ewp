# IAR project lib_lpc_chip_11u6x.ewp, settings and files
configuration chip_11u6x_lib (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U68JBD100 NXP LPC11U68JBD100
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; config_11u6x; ../chip_common; ../../../CMSIS/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_lpc_chip_110x.out
  group csp
    ./: adc_11u6x.c chip_11u6x.c clock_11u6x.c crc_11u6x.c dma_11u6x.c gpio_11u6x.c gpiogroup_11u6x.c i2c_11u6x.c i2cm_11u6x.c iocon_11u6x.c pinint_11u6x.c pmu_11u6x.c romdiv_11u6x.c rtc_11u6x.c sct_11u6x.c ssp_11u6x.c stopwatch_11u6.c syscon_11u6x.c sysinit_11u6x.c timer_11u6x.c uart_0_11u6x.c uart_n_11u6x.c wwdt_11u6x.c
    ../chip_common/: ring_buffer.c
