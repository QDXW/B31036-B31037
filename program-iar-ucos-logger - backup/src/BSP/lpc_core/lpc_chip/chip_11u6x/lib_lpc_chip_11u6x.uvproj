# Keil uVision project lib_lpc_chip_11u6x.uvproj, settings and files
target chip_11u6x_lib (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC11U68 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x200007FF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: chip_11u6x_lib (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\chip_11u6x;..\chip_common;..\..\..\CMSIS;.\config_11U6X
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x800
  group csp
    ./: adc_11u6x.c chip_11u6x.c clock_11u6x.c dma_11u6x.c gpio_11u6x.c gpiogroup_11u6x.c i2c_11u6x.c pinint_11u6x.c pmu_11u6x.c rtc_11u6x.c sct_11u6x.c ssp_11u6x.c syscon_11u6x.c sysinit_11u6x.c timer_11u6x.c wwdt_11u6x.c crc_11u6x.c iocon_11u6x.c uart_0_11u6x.c uart_n_11u6x.c romdiv_11u6x.c i2cm_11u6x.c stopwatch_11u6.c
    ../chip_common/: ring_buffer.c
