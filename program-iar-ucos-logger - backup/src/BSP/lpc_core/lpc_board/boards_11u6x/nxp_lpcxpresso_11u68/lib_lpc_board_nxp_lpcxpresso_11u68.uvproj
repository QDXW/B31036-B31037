# Keil uVision project lib_lpc_board_nxp_lpcxpresso_11u68.uvproj, settings and files
target nxp_lpcxpresso_11u68 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC11U68 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x200007FF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: board_nxp_lpcxpresso_11u68 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\..\CMSIS;..\..\..\lpc_chip\chip_11u6x;..\..\..\lpc_chip\chip_11u6x\config_11u6x;..\..\..\lpc_chip\chip_common;..\nxp_lpcxpresso_11u68;..\..\board_common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x800
  group board_nxp_lpcxpresso_11u68
    ./: board.c board_sysinit.c
