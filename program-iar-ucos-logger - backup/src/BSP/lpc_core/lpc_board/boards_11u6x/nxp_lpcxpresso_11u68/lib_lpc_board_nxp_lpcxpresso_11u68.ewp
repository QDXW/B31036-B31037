# IAR project lib_lpc_board_nxp_lpcxpresso_11u68.ewp, settings and files
configuration nxp_lpcxpresso_11u68 (ARM)
  General.OGChipSelectEditMenu: LPC11U68JBD100 NXP LPC11U68JBD100
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\lpc_chip\chip_common; ..\..\..\lpc_chip\chip_11u6x; ..\..\..\lpc_chip\chip_11u6x\config_11u6x; ..\..\..\lpc_board\board_common; $PROJ_DIR$; ..\..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group board_nxp_lpcxpresso_11u68
    ./: board.c board_sysinit.c
